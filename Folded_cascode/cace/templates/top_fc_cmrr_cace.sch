** sch_path: Folded_cascode/cace/templates/top_fc_cmrr_cace.sch
**.subckt top_fc_cmrr_cace
x1 Balance_Level Vinp voutp VDDA voutn Vinn Iref VSSA top_fc
C1 voutn VSSA 20p m=1
C2 voutp VSSA 20p m=1
V1 VDDA VSSA VDDA
V3 VSSA 0 0
V4 Balance_Level VSSA Balance_Level
I0 Iref VSSA 1u
E1 Vout VSSA voutp voutn 1
* noconn Vout
Bvinp Vinp VSSA V = {VCM+V(Vdiff)/2 + V(Vcmac)}
Bvinn Vinn VSSA V = {VCM-V(Vdiff)/2 + V(Vcmac)}
vdiff Vdiff VSSA dc 0 ac 1
vcmac Vcmac VSSA dc 0 ac 0
**** begin user architecture code

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}



.temp CACE{temperature}
.param VDDA = CACE{vdd}
.param Balance_Level = CACE{balance_level}
.param VCM = CACE{vcm}
.include CACE{DUT_path}

.control
set noaskquit
set filetype=ascii
set wr_singlescale
set wr_vecnames

* First AC sweep: differential input AC=1, common-mode AC=0.
alter @Vdiff[acmag] = 1
alter @Vcmac[acmag] = 0
ac dec 100 1 1G
let vod = v(voutp) - v(voutn)
let ad = vod / v(Vdiff)
let ad_db = db(ad)
meas ac ad_1hz FIND ad_db AT=1

* Second AC sweep: differential input AC=0, common-mode AC=1.
alter @Vdiff[acmag] = 0
alter @Vcmac[acmag] = 1
ac dec 100 1 1G
let vod_cm = v(voutp) - v(voutn)
let acm = vod_cm / v(Vcmac)
let acm_db = db(acm)
meas ac acm_1hz FIND acm_db AT=1

* Compare both differential-output responses (ac1 vs ac2).
let cmrr_db = ac1.ad_db - acm_db
meas ac cmrr_1hz FIND cmrr_db AT=1
meas ac cmrr_1k FIND cmrr_db AT=1k
meas ac cmrr_10k FIND cmrr_db AT=10k
meas ac cmrr_100k FIND cmrr_db AT=100k
meas ac cmrr_1meg FIND cmrr_db AT=1Meg
meas ac cmrr_10meg FIND cmrr_db AT=10Meg

let ad_1hz_saved = ac1.ad_1hz
print ad_1hz_saved acm_1hz cmrr_1hz cmrr_1k cmrr_10k cmrr_100k cmrr_1meg cmrr_10meg
echo $&ad_1hz_saved $&acm_1hz $&cmrr_1hz $&cmrr_1k $&cmrr_10k $&cmrr_100k $&cmrr_1meg $&cmrr_10meg >
+ CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
