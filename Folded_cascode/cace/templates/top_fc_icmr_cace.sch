** sch_path: Folded_cascode/cace/templates/top_fc_icmr_cace.sch
**.subckt top_fc_icmr_cace
x1 Balance_Level Vinp voutp VDDA voutn Vinn Iref VSSA top_fc
C1 voutn VSSA 20p m=1
C2 voutp VSSA 20p m=1
V1 VDDA VSSA VDDA
V3 VSSA 0 0
V4 Balance_Level VSSA Balance_Level
I0 Iref VSSA 1u
Bvinp Vinp VSSA V = {V(Vcm_node) + V(Vdiff)/2}
Bvinn Vinn VSSA V = {V(Vcm_node) - V(Vdiff)/2}
Vcm Vcm_node VSSA CACE{vcm}
Vdiff Vdiff VSSA dc 0 ac 1
**** begin user architecture code

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}



.temp CACE{temperature}
.param VDDA = CACE{vdd}
.param Balance_Level = CACE{balance_level}

* Same DC operating point and 1 Hz AC gain sweep as top_fc_icmr_tb.sch
* CACE writes two columns per point for its postprocess script.
.include CACE{DUT_path}

.control
set noaskquit
set filetype=ascii
set wr_singlescale
set wr_vecnames

setplot const
let vcm_val = 0
let vcm_stop = CACE{vdd}
let vcm_step = 0.01

* Each CACE run writes an independent result file.
shell rm -f CACE{simpath}/CACE{filename}_CACE{N}.data

while vcm_val <= vcm_stop
    alter @Vcm[dc] = $&vcm_val
    ac lin 1 1 1
    let vod = v(voutp) - v(voutn)
    let ad = vod / v(Vdiff)
    let gain_now = db(ad)
    echo $&const.vcm_val $&gain_now >> CACE{simpath}/CACE{filename}_CACE{N}.data
    setplot const
    let vcm_val = vcm_val + vcm_step
end

alter @Vcm[dc] = CACE{vcm}
.endc


**** end user architecture code
**.ends
.end
