** sch_path: Folded_cascode/cace/templates/top_fc_op_cace.sch
**.subckt top_fc_op_cace
x1 Balance_Level Vin voutp VDDA voutn Vin Iref VSSA top_fc
V2 Vin VSSA CACE{vcm}
C1 voutn VSSA 20p m=1
C2 voutp VSSA 20p m=1
V1 VDDA VSSA VDDA
V3 VSSA 0 0
V4 Balance_Level VSSA Balance_Level
I0 Iref VSSA 1u
**** begin user architecture code

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}



.temp CACE{temperature}
.param VDDA = CACE{vdd}
.param Balance_Level = CACE{balance_level}
.param VCM = CACE{vcm}
.param sw_stat_global=0
.param sw_stat_mismatch=0
.include CACE{DUT_path}

.control
set noaskquit
set filetype=ascii
set wr_singlescale
set wr_vecnames

* Preserve operating point in a separate raw file for device-level inspection.
save all
op
write CACE{simpath}/top_fc_op_CACE{N}.raw all
let voutp_dc = v(voutp)
let voutn_dc = v(voutn)
let vout_diff_dc = v(voutp)-v(voutn)
let vout_cm_dc = (v(voutp)+v(voutn))/2
print voutp_dc voutn_dc vout_diff_dc vout_cm_dc
echo $&voutp_dc $&voutn_dc $&vout_diff_dc $&vout_cm_dc > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
