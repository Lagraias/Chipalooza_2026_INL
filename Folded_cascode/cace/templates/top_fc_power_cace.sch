** sch_path: Folded_cascode/cace/templates/top_fc_power_cace.sch
**.subckt top_fc_power_cace
C1 voutn VSSA 20p m=1
C2 voutp VSSA 20p m=1
V1 VDDA VSSA VDDA
V3 VSSA 0 0
V4 Balance_Level VSSA Balance_Level
I0 Iref VSSA 1u
Bvinp Vinp VSSA V = {VCM + V(Vdiff)/2}
Bvinn Vinn VSSA V = {VCM - V(Vdiff)/2}
Vdiff Vdiff VSSA 0
x1 VDDA_BIAS VDDA_OTA VDDA_CMFB Balance_Level Vinp voutp voutn Vinn Iref VSSA top_fc_power
Vamm1 VDDA VDDA_OTA 0
.save i(vamm1)
Vamm2 VDDA VDDA_CMFB 0
.save i(vamm2)
Vamm3 VDDA VDDA_BIAS 0
.save i(vamm3)
**** begin user architecture code

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}



.temp CACE{temperature}
.param VDDA = CACE{vdd}
.param Balance_Level = CACE{balance_level}
.param VCM = CACE{vcm}
.param VD = 0
.param sw_stat_global=0
.param sw_stat_mismatch=0

.include CACE{DUT_path}

.control
set noaskquit
set filetype=ascii
set wr_singlescale
set wr_vecnames
op

* Ammeter source currents, the convention used in the original testbench.
let i_ota = abs(i(Vamm1))
let i_cmfb = abs(i(Vamm2))
let i_bias = abs(i(Vamm3))
let i_total = i_ota + i_cmfb + i_bias

* Export power in W; CACE formats in mW using YAML unit metadata.
let p_ota = CACE{vdd} * i_ota
let p_cmfb = CACE{vdd} * i_cmfb
let p_bias = CACE{vdd} * i_bias
let p_total = p_ota + p_cmfb + p_bias

* Return readable engineering units for all conditions.
let i_ota_uA = i_ota * 1e6
let i_cmfb_uA = i_cmfb * 1e6
let i_bias_uA = i_bias * 1e6
let i_total_uA = i_total * 1e6

print i_ota_uA i_cmfb_uA i_bias_uA i_total_uA
print p_ota p_cmfb p_bias p_total

echo $&i_ota_uA $&i_cmfb_uA $&i_bias_uA $&i_total_uA $&p_ota $&p_cmfb $&p_bias $&p_total > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
