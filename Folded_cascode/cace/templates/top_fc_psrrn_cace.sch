** sch_path: Folded_cascode/cace/templates/top_fc_psrrn_cace.sch
**.subckt top_fc_psrrn_cace
x1 Balance_Level Vin voutp VDDA voutn Vin Iref VSSA top_fc
V2 Vin VSSA CACE{vcm}
C1 voutn VSSA 20p m=1
C2 voutp VSSA 20p m=1
V1 VDDA VSSA DC VDDA AC 0
V3 VSSA 0 DC 0 AC 1
V4 Balance_Level VSSA DC Balance_Level AC 0
I0 Iref VSSA DC 1u AC 0
**** begin user architecture code

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}



.temp CACE{temperature}
.param VDDA = CACE{vdd}
.param Balance_Level = CACE{balance_level}
.include CACE{DUT_path}

.control
set noaskquit
set filetype=ascii
save v(voutp) v(voutn) v(VDDA) v(VSSA)
ac dec 100 1 1G

* Source magnitude AC = 1 V; calculate supply-to-differential
* and supply-to-common-mode transfer functions.
let vod = v(voutp)-v(voutn)
let vocm = (v(voutp)+v(voutn))/2
let aps_diff = vod/v(VSSA)
let aps_cm = vocm/v(VSSA)
let psrr_diff = -db(aps_diff)
let psrr_cm = -db(aps_cm)
meas ac psrrn_diff_1hz FIND psrr_diff AT=1
meas ac psrrn_diff_1k FIND psrr_diff AT=1k
meas ac psrrn_diff_10k FIND psrr_diff AT=10k
meas ac psrrn_diff_100k FIND psrr_diff AT=100k
meas ac psrrn_diff_1meg FIND psrr_diff AT=1Meg
meas ac psrrn_diff_10meg FIND psrr_diff AT=10Meg
meas ac psrrn_cm_1hz FIND psrr_cm AT=1
meas ac psrrn_cm_1k FIND psrr_cm AT=1k
meas ac psrrn_cm_10k FIND psrr_cm AT=10k
meas ac psrrn_cm_100k FIND psrr_cm AT=100k
meas ac psrrn_cm_1meg FIND psrr_cm AT=1Meg
meas ac psrrn_cm_10meg FIND psrr_cm AT=10Meg

print psrrn_diff_1hz psrrn_diff_1k psrrn_diff_10k psrrn_diff_100k psrrn_diff_1meg psrrn_diff_10meg
+ psrrn_cm_1hz psrrn_cm_1k psrrn_cm_10k psrrn_cm_100k psrrn_cm_1meg psrrn_cm_10meg
echo $&psrrn_diff_1hz $&psrrn_diff_1k $&psrrn_diff_10k $&psrrn_diff_100k $&psrrn_diff_1meg $&psrrn_diff_10meg
+ $&psrrn_cm_1hz $&psrrn_cm_1k $&psrrn_cm_10k $&psrrn_cm_100k $&psrrn_cm_1meg $&psrrn_cm_10meg > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
