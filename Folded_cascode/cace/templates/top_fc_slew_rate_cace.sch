** sch_path: Folded_cascode/cace/templates/top_fc_slew_rate_cace.sch
**.subckt top_fc_slew_rate_cace
x1 Balance_Level Vinp voutp VDDA voutn Vinn Iref VSSA top_fc
C1 voutn VSSA 20p m=1
C2 voutp VSSA 20p m=1
V1 VDDA VSSA VDDA
V3 VSSA 0 0
V4 Balance_Level VSSA Balance_Level
I0 Iref VSSA 1u
Bvinp Vinp VSSA V = {VCM + (V(Vcmd)-(V(voutp)-V(voutn)))/2}
Bvinn Vinn VSSA V = {VCM - (V(Vcmd)-(V(voutp)-V(voutn)))/2}
Vcmd Vcmd VSSA PULSE(-0.8 0.8 5u 1n 1n 20u 100u)
**** begin user architecture code

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}



.temp CACE{temperature}
.param VDDA = CACE{vdd}
.param Balance_Level = CACE{balance_level}
.param VCM = CACE{vcm}
.param VD = 0
.param sw_stat_global=0
.param sw_stat_mismatch=0
.include CACE{DUT_path}

.control
set noaskquit
set filetype=ascii
save v(Vcmd) v(voutp) v(voutn)
tran 10n 45u
let vod = v(voutp)-v(voutn)
let dvod_dt = deriv(vod)

* Reuse nominal testbench definitions and thresholds.
meas tran sr_pos MAX dvod_dt
meas tran sr_neg MIN dvod_dt
let sr_pos_vus = sr_pos*1e-6
let sr_neg_vus = abs(sr_neg)*1e-6
meas tran t_rise_10 WHEN vod=-0.64 RISE=1
meas tran t_rise_90 WHEN vod=0.64 RISE=1
meas tran t_fall_90 WHEN vod=0.64 FALL=1
meas tran t_fall_10 WHEN vod=-0.64 FALL=1
let tr_10_90_s = t_rise_90-t_rise_10
let tf_90_10_s = t_fall_10-t_fall_90
let sr_rise_10_90_vus = (1.28/tr_10_90_s)*1e-6
let sr_fall_90_10_vus = (1.28/tf_90_10_s)*1e-6

print sr_pos_vus sr_neg_vus sr_rise_10_90_vus sr_fall_90_10_vus tr_10_90_s tf_90_10_s
echo $&sr_pos_vus $&sr_neg_vus $&sr_rise_10_90_vus $&sr_fall_90_10_vus $&tr_10_90_s $&tf_90_10_s > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



**** end user architecture code
**.ends
.end
