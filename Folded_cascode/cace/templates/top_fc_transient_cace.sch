** sch_path: Folded_cascode/cace/templates/top_fc_transient_cace.sch
**.subckt top_fc_transient_cace
x1 Balance_Level Vinp voutp VDDA voutn Vinn Iref VSSA top_fc
C1 voutn VSSA 20p m=1
C2 voutp VSSA 20p m=1
V1 VDDA VSSA VDDA
V3 VSSA 0 0
V4 Balance_Level VSSA Balance_Level
I0 Iref VSSA 1u
V9 Vinn VSSA PULSE(2.499975 2.500025 1u 1n 1n 10u 20u)
V10 Vinp VSSA PULSE(2.500025 2.499975 1u 1n 1n 10u 20u)
**** begin user architecture code

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}



.temp CACE{temperature}
.param VDDA = CACE{vdd}
.param Balance_Level = CACE{balance_level}
.param VCM = CACE{vcm}
.param VD = 0
.param sw_stat_global=0
.param sw_stat_mismatch=0
.include CACE{DUT_path}

.control
set noaskquit
set filetype=ascii
save v(vinp) v(vinn) v(voutp) v(voutn)
tran 10n 50u
let vid = v(vinp)-v(vinn)
let vod = v(voutp)-v(voutn)
let vocm = (v(voutp)+v(voutn))/2

* Nominal testbench only saved waveforms. Add scalar measurements for CACE.
meas tran vid_max MAX vid
meas tran vid_min MIN vid
meas tran vod_max MAX vod
meas tran vod_min MIN vod
meas tran vod_rms RMS vod
meas tran vocm_min MIN vocm
meas tran vocm_max MAX vocm
let vid_pp = vid_max-vid_min
let vod_pp = vod_max-vod_min

print vid_pp vod_pp vod_rms vocm_min vocm_max
echo $&vid_pp $&vod_pp $&vod_rms $&vocm_min $&vocm_max > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



**** end user architecture code
**.ends
.end
