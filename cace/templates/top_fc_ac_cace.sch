** sch_path: cace/templates/top_fc_ac_cace.sch
**.subckt top_fc_ac_cace
x1 Balance_Level Vinp voutp VDDA voutn Vinn Iref VSSA top_fc
C1 voutn VSSA 20p m=1
C2 voutp VSSA 20p m=1
V1 VDDA VSSA VDDA
V3 VSSA 0 0
V4 Balance_Level VSSA Balance_Level
I0 Iref VSSA 1u
V5 Vinp VSSA CACE{vcm}
V9 Vinn Vinp dc 0 ac 1
E1 Vout VSSA voutp voutn 1
* noconn Vout
**** begin user architecture code

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}



.temp CACE{temperature}
.param VDDA = CACE{vdd}
.param Balance_Level = CACE{balance_level}

* Use the DUT subcircuit generated or selected by CACE.
.include CACE{DUT_path}

.control
set noaskquit
set filetype=ascii
set wr_singlescale
set wr_vecnames
save v(vinp) v(vinn) v(voutp) v(voutn)

ac dec 100 1 1G

let vid = v(vinp) - v(vinn)
let vod = v(voutp) - v(voutn)
let ad = vod / vid
let gain_db = db(ad)
let phase_deg = (180/pi)*ph(ad)

meas ac gain_dc FIND gain_db AT=1
meas ac fu WHEN gain_db=0 CROSS=1
meas ac phase_fu FIND phase_deg AT=fu
let pm = 180 + phase_fu

print gain_dc fu phase_fu pm

* Each CACE run has its own output filename.
echo $&gain_dc $&fu $&pm > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
