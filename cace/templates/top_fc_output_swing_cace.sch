** sch_path: cace/templates/top_fc_output_swing_cace.sch
**.subckt top_fc_output_swing_cace
x1 Balance_Level Vinp voutp VDDA voutn Vinn Iref VSSA top_fc
C1 voutn VSSA 20p m=1
C2 voutp VSSA 20p m=1
V1 VDDA VSSA VDDA
V3 VSSA 0 0
V4 Balance_Level VSSA Balance_Level
I0 Iref VSSA 1u
Bvinp Vinp VSSA V = {VCM + (V(Vcmd)-(V(voutp)-V(voutn)))/2}
Bvinn Vinn VSSA V = {VCM - (V(Vcmd)-(V(voutp)-V(voutn)))/2}
Vdiff Vdiff VSSA 0
Vcmd Vcmd VSSA 0
**** begin user architecture code

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}



.temp CACE{temperature}
.param VDDA = CACE{vdd}
.param Balance_Level = CACE{balance_level}
.param VCM = CACE{vcm}
.param sw_stat_global=0
.param sw_stat_mismatch=0
.include CACE{DUT_path}

.control
set noaskquit
set filetype=ascii
set wr_singlescale

* Retain original command sweep and four output device saturation margins.
save all
save @m.x1.x1.xm6.m0[vds]
save @m.x1.x1.xm6.m0[vdsat]
save @m.x1.x1.xm7.m0[vds]
save @m.x1.x1.xm7.m0[vdsat]
save @m.x1.x1.xm8.m0[vds]
save @m.x1.x1.xm8.m0[vdsat]
save @m.x1.x1.xm10.m0[vds]
save @m.x1.x1.xm10.m0[vdsat]

dc Vcmd -4.5 4.5 5m

let vod = v(voutp)-v(voutn)
let vocm = (v(voutp)+v(voutn))/2
let tracking_error = vod-v(Vcmd)
let sat_xm6 = abs(@m.x1.x1.xm6.m0[vds])-abs(@m.x1.x1.xm6.m0[vdsat])
let sat_xm7 = abs(@m.x1.x1.xm7.m0[vds])-abs(@m.x1.x1.xm7.m0[vdsat])
let sat_xm8 = abs(@m.x1.x1.xm8.m0[vds])-abs(@m.x1.x1.xm8.m0[vdsat])
let sat_xm10 = abs(@m.x1.x1.xm10.m0[vds])-abs(@m.x1.x1.xm10.m0[vdsat])

* With wr_singlescale, the sweep command voltage is column one.
* Further columns: voutp voutn vod vocm error sat_xm6 sat_xm7 sat_xm8 sat_xm10.
wrdata CACE{simpath}/CACE{filename}_CACE{N}.data v(voutp) v(voutn) vod vocm tracking_error sat_xm6 sat_xm7
+ sat_xm8 sat_xm10
.endc


**** end user architecture code
**.ends
.end
