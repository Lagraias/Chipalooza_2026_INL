** sch_path: cace/templates/top_fc_psrrp_cace.sch
**.subckt top_fc_psrrp_cace
x1 Balance_Level Vin voutp VDDA voutn Vin Iref VSSA top_fc
V2 Vin VSSA CACE{vcm}
C1 voutn VSSA 20p m=1
C2 voutp VSSA 20p m=1
V1 VDDA VSSA DC VDDA AC 1
V3 VSSA 0 DC 0 AC 0
V4 Balance_Level VSSA DC Balance_Level AC 0
I0 Iref VSSA DC 1u AC 0
**** begin user architecture code

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}



.temp CACE{temperature}
.param VDDA = CACE{vdd}
.param Balance_Level = CACE{balance_level}
.include CACE{DUT_path}

.control
set noaskquit
set filetype=ascii
save v(voutp) v(voutn) v(VDDA) v(VSSA)
ac dec 100 1 1G

* Source magnitude AC = 1 V; calculate supply-to-differential
* and supply-to-common-mode transfer functions.
let vod = v(voutp)-v(voutn)
let vocm = (v(voutp)+v(voutn))/2
let aps_diff = vod/v(VDDA)
let aps_cm = vocm/v(VDDA)
let psrr_diff = -db(aps_diff)
let psrr_cm = -db(aps_cm)
meas ac psrrp_diff_1hz FIND psrr_diff AT=1
meas ac psrrp_diff_1k FIND psrr_diff AT=1k
meas ac psrrp_diff_10k FIND psrr_diff AT=10k
meas ac psrrp_diff_100k FIND psrr_diff AT=100k
meas ac psrrp_diff_1meg FIND psrr_diff AT=1Meg
meas ac psrrp_diff_10meg FIND psrr_diff AT=10Meg
meas ac psrrp_cm_1hz FIND psrr_cm AT=1
meas ac psrrp_cm_1k FIND psrr_cm AT=1k
meas ac psrrp_cm_10k FIND psrr_cm AT=10k
meas ac psrrp_cm_100k FIND psrr_cm AT=100k
meas ac psrrp_cm_1meg FIND psrr_cm AT=1Meg
meas ac psrrp_cm_10meg FIND psrr_cm AT=10Meg

print psrrp_diff_1hz psrrp_diff_1k psrrp_diff_10k psrrp_diff_100k psrrp_diff_1meg psrrp_diff_10meg
+ psrrp_cm_1hz psrrp_cm_1k psrrp_cm_10k psrrp_cm_100k psrrp_cm_1meg psrrp_cm_10meg
echo $&psrrp_diff_1hz $&psrrp_diff_1k $&psrrp_diff_10k $&psrrp_diff_100k $&psrrp_diff_1meg $&psrrp_diff_10meg
+ $&psrrp_cm_1hz $&psrrp_cm_1k $&psrrp_cm_10k $&psrrp_cm_100k $&psrrp_cm_1meg $&psrrp_cm_10meg > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
