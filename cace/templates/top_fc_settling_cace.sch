** sch_path: cace/templates/top_fc_settling_cace.sch
**.subckt top_fc_settling_cace
x1 Balance_Level Vinp voutp VDDA voutn Vinn Iref VSSA top_fc
C1 voutn VSSA 20p m=1
C2 voutp VSSA 20p m=1
V1 VDDA VSSA VDDA
V3 VSSA 0 0
V4 Balance_Level VSSA Balance_Level
I0 Iref VSSA 1u
Bvinp Vinp VSSA V = {VCM + (V(Vcmd)-(V(voutp)-V(voutn)))/2}
Bvinn Vinn VSSA V = {VCM - (V(Vcmd)-(V(voutp)-V(voutn)))/2}
Vcmd Vcmd VSSA PULSE(-0.8 0.8 5u 1n 1n 20u 100u)
**** begin user architecture code

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}



.temp CACE{temperature}
.param VDDA = CACE{vdd}
.param Balance_Level = CACE{balance_level}
.param VCM = CACE{vcm}
.param VD = 0
.param sw_stat_global=0
.param sw_stat_mismatch=0
.include CACE{DUT_path}

.control
set noaskquit
set filetype=ascii
set wr_singlescale
save all
tran 1n 45u
let vod = v(voutp)-v(voutn)
let vocm = (v(voutp)+v(voutn))/2
let tracking_error = vod-v(Vcmd)
wrdata CACE{simpath}/CACE{filename}_CACE{N}.data v(Vcmd) vod vocm tracking_error
.endc



**** end user architecture code
**.ends
.end
