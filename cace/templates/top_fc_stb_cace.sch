** sch_path: cace/templates/top_fc_stb_cace.sch
**.subckt top_fc_stb_cace
V2 Vin VSSA 2.5
C1 voutn VSSA 20p m=1
C2 voutp VSSA 20p m=1
V1 VDDA VSSA VDDA
V3 VSSA 0 0
V4 Balance_Level VSSA Balance_Level
I0 Iref VSSA 1u
x1 CMFB_out Vb4 Balance_Level Vin voutp VDDA voutn Vin Iref VSSA top_fc_stb
V9 Vb4 CMFB_out dc 0 ac 1
**** begin user architecture code

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}



.temp CACE{temperature}
.param VDDA = CACE{vdd}
.param Balance_Level = CACE{balance_level}

* Include the separate STB circuit, generated by CACE from top_fc_stb.sch.
.include CACE{DUT_path}

.control
set noaskquit
set filetype=ascii
set wr_singlescale
set wr_vecnames
save v(CMFB_out) v(Vb4)
ac dec 100 1 1G

* Preserve the loop-gain convention of the original STB testbench.
let loopgain = -v(CMFB_out)/v(Vb4)
let lg_db = db(loopgain)
let lg_phase_deg = phase(loopgain)*180/3.141592653589793

meas ac f_ugf1 WHEN lg_db=0 CROSS=1
meas ac phase_ugf1 FIND lg_phase_deg AT=f_ugf1
let pm1 = 180 + phase_ugf1

print f_ugf1 phase_ugf1 pm1

echo $&f_ugf1 $&pm1 > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.end
